# Keil uVision project 多功能数字钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 数码管秒表 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App
  group User
    ./User/: main.c
  group App
    ./App/: smg.c beep.c key.c time.c
  group Public
    ./Public/: public.c
